Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-09-14T01:44:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 14 01:44:41 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{99D9F239-0017-45DE-B3CC-16147DA26814}\ifc * Database version: 5507 * Database creation date: Fri Sep 14 01:44:40 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 14 01:44:40 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 14 01:44:40 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 45202283 Kitchen faucet with dishwasher valve, 45202283:45202283 Kitchen faucet with dishwasher valve:321403
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 16 mm; NominalDepth: 251 mm; NominalHeight: 163 mm; NominalWidth: 54 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 45202283; ConvergoRefNr: 0087-1809-0174-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with dishwasher valve with ceramic cartridge 90° rotation for ON/OFF; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 14/09/2018
Type - Green Building Properties(Type) - EAN Number: 4057304003660
Type - Identity Data(Type) - Class: Single lever; Group: Kitchen faucets; Manufacturer: Hansa; Market: AUT;BEL;CZE;DEU;ESP;FRA;INT;ITA;NLD; Model: 45202283 Kitchen faucet with dishwasher valve; Name_en: 45202283 Kitchen faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 45202283; Product Datasheet: http://dbint.hansa.com/index.php?pdf=true&pdfType=prod&catType=p; Product Family: HANSAPINTO; Product URL: http://dbint.hansa.com/index.php?IdProduct=108796&IdTreeGroup=2576; Type Name: 45202283 Kitchen faucet with dishwasher valve
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Aerator: Aerator; Connection Size: G3/8; Dishwasher Valve: Washing machine valve; Flow: Limitation option for maximum flowrate; Installation and Maintenance: http://dbint.hansa.com/media/hansa_sanitaer/bedienungsanleitungen/print/aktuell/4500/M45202283_a.pdf; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipes; Spare Parts: http://dbint.hansa.com/index.php?pdf=true&pdfType=prod&catType=p; Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 45202283; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 45202283; Name: 45202283 Kitchen faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: 54x251x163 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 45202283; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 45202283 Kitchen faucet with dishwasher valve
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.065179 m2; Volume: 0.00222137 m3
Identity Data - Mark: 6
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 45202283: 45202283 Kitchen faucet with dishwasher valve; Family and Type: 45202283: 45202283 Kitchen faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 45202283: 45202283 Kitchen faucet with dishwasher valve; Type Id: 45202283: 45202283 Kitchen faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
